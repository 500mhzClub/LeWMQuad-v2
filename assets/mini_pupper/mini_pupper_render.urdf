Commit message: Fixxing body clipping

File: assets/mini_pupper/mini_pupper_render.urdf (robot description, URDF)
Before this commit: robot mini_pupper, 18 links, 17 joints
Links:
- link base_link: geometry collision box size=0.18110 0.07000 0.07000
